options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: receive
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bandwith
  id: variable_qtgui_range
  parameters:
    label: Reception bandwith (Hz)
    outputmsgname: value
    showports: 'False'
    start: samp_rate / 100
    step: '1'
    stop: samp_rate / 2
    value: samp_rate / 8
  states: {}
- name: dc_offset_correction
  id: variable
  parameters:
    value: samp_rate / 4
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: 1e3
    stop: 3e9
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: (dc_offset_correction + bandwith)
    low_cutoff_freq: (dc_offset_correction -bandwith)
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../cap.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '150e-3'
    init: '0'
    low: '50e-3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: ook2bin
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach this file is saved, GRC will instantiate the first class it finds to get          в секунде миллион микросекунд т.е делитель 2\nports and parameters of your block. The arguments to __init__  will be the\nparameters. All of them are required to have default values!\n\"\"\"\nimport time\nimport numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nclass blk (gr.sync_block):\n    \"\"\"\n    Block to decode the data on an already squared signal, comprised of 0's and 1's.\n    \"\"\"\n\n    def __init__ (self\n                , baseband_freq = 600\n                , sample_rate = 2e6\n                , sink_file = None):  # only default arguments here\n        \"\"\"\n        Constructor.\n\n        Args:\n            baseband_freq -> Frequency of the baseband signal\n\n            sample_rate -> Number of samples per second\n\n            sink_file -> File to dump the packets. If it's 'None', prints them on STDOUT\n        \"\"\"\n        gr.sync_block.__init__(\n            self,\n            name = 'OOK to bin sink',\n            in_sig = [np.float32],\n            out_sig = []\n        )\n\n        # Number of samples to discern long and short bursts\n        #   sample_rate / baseband_freq = samples_per_period\n        self.threshold = (sample_rate / baseband_freq) / 2\n\n        self.sink_file = sink_file\n\n        self.time_delta = 0 # Timer to measure the time between edges\n\n        self.rising_timestamps = []\n        self.falling_timestamps = []\n        self.previous_sample = 0  #posl sig rx\n        self.lastRxValue = 1\n        self.Rxpin = 0  #posl sig rx\n\n        # Counter to determine the end of a packet. If more than (2 * threshold) samples\n        # are set to 0, the packet is done\n        self.allzero_count = 0\n        self.starline_counter_pre = 0\n        self.starline_counter = 0\n        self.staline_state = 0\n        self.bValidPacket=False\n        self.lastRxTime=0\n        self.lastRx=0\n        self.difTime=0\n        self.tempTime=0\n        self.packet = [] # List to store the bits of the packet\n        self.starline_code= [0,0,0,0,0,0,0,0]\n        self.state = 0\n        self.sym_count = 0\n        self.bit_count = 0\n        self.byte = 0\n        self.sym = 0\n        self.packet = []        \n        self.dt = datetime.now()\n        self.mic=self.dt.microsecond\n\n    def reset_state(self):\n        self.state = 0\n        self.sym_count = 0\n        self.bit_count = 0\n        self.byte = 0\n        self.sym = 0\n        self.packet = []\n    def decodestarline (self) :\n        if (self.difTime >900*2 and self.difTime <1100*2 and self.staline_state ==0  and self.lastRx==1):\n           #print(\"starline preambule\")\n           self.starline_counter_pre +=1\n           if self.starline_counter_pre == 6:\n                print(\"starline preambule\")\n                self.staline_state = 1  \n                # print(self.difTime)              \n        # preambule good      \n        elif (self.staline_state==1):\n            if (self.difTime >350*2 and self.difTime <650*2 and self.lastRx==1): \n                self.packet.append (\"0\")\n                self.bValidPacket = True\n            elif (self.difTime >150*2 and self.difTime <350*2 and self.lastRx==1): \n                self.packet.append (\"1\")\n                self.bValidPacket = True\n            else: \n                self.staline_state = 1 \n                self.starline_counter=0\n            if(self.bValidPacket ==True):\n               self.starline_counter+=1\n               # print(self.starline_counter)\n               if(self.starline_counter==64):\n                  print(\"getcode\")\n                  self.starline_counter=0 \n                  self.staline_state=0\n                  self.time_delta=0\n                  self.starline_counter_pre=0                           \n                  #bin_strstar = str (self.packet)                                 \n                 # print(self.packet)  \n                  print(self.packet)                                \n                  self.packet = []\n                 \n\n\n\n    def work (self, input_items, *args, **kwargs):\n    \n        \n    \n        samples = input_items [0]\n        \n        in0 = input_items[0]\n        processed = 0    \n        \n\n        for i in range(0, len(input_items[0])):\n            self.time_delta += 1\n            self.Rxpin=round(input_items[0][i])\n            if(self.Rxpin!=self.lastRx):\n                self.tempTime=self.time_delta\n                self.difTime=self.tempTime-self.lastRxTime\n                # print(self.difTime)\n                self.decodestarline()\n                self.lastRxTime=self.tempTime\n                self.lastRx=self.Rxpin\n                \n                \n               \n            \n        \n        # for sym in in0:\n            # print(in0)\n            \n        #self.time_delta += len (samples)\n        \n        # if self.time_delta>1000000 and self.time_delta<2000005:\n            # print(self.time_delta)\n            # print(self.Rxpin)\n\n                \n\n\n        #self.consume(0, len(input_items[0]))     ///uvelichivaet kakto v hz   \n        \n        #print(self.time_delta)\n\n        return len (samples)\n\n\n"
    baseband_freq: '600'
    sample_rate: '2000000.0'
    sink_file: None
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    freq0: freq + dc_offset_correction
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tabs@0
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@2
    label1: ''
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"pila"'
    size: '30000'
    srate: samp_rate
    type: float
    update_time: '0.001'
    ymin: '0'
    yunit: '"bin"'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Original signal
    label1: Squared signal
    label2: Processed signal
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '12'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '12'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0, '0', ook2bin, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
