options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: receive
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bandwith
  id: variable_qtgui_range
  parameters:
    label: Reception bandwith (Hz)
    orient: Qt.Horizontal
    start: samp_rate / 10000
    step: '1'
    stop: samp_rate / 10
    value: samp_rate / 100
  states: {}
- name: dc_offset_correction
  id: variable
  parameters:
    value: samp_rate / 4
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    orient: Qt.Horizontal
    start: '0'
    step: 1e3
    stop: 3e9
    value: 433e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: (dc_offset_correction + bandwith)
    low_cutoff_freq: (dc_offset_correction -bandwith)
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 5e4
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../cap.iq
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '150e-3'
    init: '0'
    low: '100e-3'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '1'
    freq0: freq + dc_offset_correction
    gain0: gain
    gain_mode0: 'False'
    if_gain0: gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tabs@0
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@2
    label1: ''
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"pila"'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
    update_time: '0.0001'
    ymin: '0'
    yunit: ''
  states: {}
- name: starline_starline_decode_0
  id: starline_starline_decode
  parameters:
    selector: 'True'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Original signal
    label1: Squared signal
    label2: Processed signal
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '12'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '12'
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_threshold_ff_0, '0', starline_starline_decode_0, '0']
- [blocks_threshold_ff_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_0, '0']
- [starline_starline_decode_0, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
